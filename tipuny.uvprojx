# Keil uVision project tipuny.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40X_HD
  c include: .\GeneralFunction\inc;.\Libraries\CMSIS;.\Libraries\Startup;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\uCOSII\CONFIG;.\uCOSII\CORE;.\uCOSII\PORT;.\USER\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/SRC/: main.c stm32f4xx_it.c DJ3508.c
    ./USER/INC/: macro.h
  group Peripheral
    ./USER/SRC/: tim2.c tim3.c can1.c can2.c usart1.c led8.c led.c beep.c cylinder.c usart3.c
  group MyFunc
    ./USER/SRC/: param.c queue.c canctrllist.c pid.c mathFunc.c delay.c mech.c switch.c
  group motor&driver
    ./USER/SRC/: DJmotor.c vesc.c Tmotor.c zdrive.c
  group GeneralFunction
    ./GeneralFunction/src/: dma.c visual_scope.c sys.c
  group LIB
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group STARTUP
    ./Libraries/Startup/: startup_stm32f4xx.s
  group uCOS/CORE
    ./uCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uCOS/PORT
    ./uCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS/CONFIG
    ./uCOSII/CONFIG/: includes.h os_cfg.h
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
